FILESEXTRAPATHS_prepend := "${THISDIR}:"
SRC_URI_append = " file://linux-kernel.cfg \
                   file://qcom8x96.cfg "

